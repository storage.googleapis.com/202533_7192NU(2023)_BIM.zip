Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-07-27T17:15:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 27 17:15:06 2023 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\97c79391-b754-4c89-a49f-13133762cc2a\b9da3edc-eb82-4d3c-ba82-b54f3665bbd0\ifc * Database version: 5507 * Database creation date: Thu Jul 27 17:15:03 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 27 17:15:03 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 27 17:15:03 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 7192NU Shower system, 7192NU(2023):7192NU Shower system:442841
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 610.958 mm; FaucetNominalHeight: 1238.43 mm; FaucetNominalWidth: 342.373 mm
Type - General - Author: BIMStone; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150099588; EN Standard: EN1111; ETIM Class Number: EC011329 Shower mixing tap; Noise Class 02ls: I (ISO 3822); Sales Package dimensions (LxWxH): 1119 x 253 x 108; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7192NU; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7192NU
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7192NU; 3D View: https://static.oras.com/AR/7192NU; Catalog Drawing URL: http://static.oras.com/catdrw/7192NU; Dimension Drawing URL: http://static.oras.com/dimdrw/7192NU; FDV Document URL: http://www.oras.com/datasheet/7192NU/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7192NU; Group: Shower system; Installation and Maintenance Guide URL: http://static.oras.com/manual/7192NU; Interactive AR View URL: https://static.oras.com/AR/7192NU; Manufacturer: Oras; Market: Estonia;International;Lithuania;Latvia;Poland;Ukraine; Mobile Product Information URL: http://mpi.oras.com/7192NU; Model: 7192NU Shower system; Name_en: 7192NU Shower system; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7192NU; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/7192NU; Product URL: http://static.oras.com/7192NU; Technical DataSheet URL: http://www.oras.com/datasheet/7192NU/en; Type Name: 7192NU Shower system; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Flexible length / can be shortened;Hose guide, revolving; Backflow Prevention EN1717: EB; Connection: Eccentric coupling(s);Cover plate(s);Silencer(s); Connection Size: G3/4; Diverter: Turn operated diverter;Integrated into flow control handle; Eco Flow At 300kPa: 0.00423776 m3/s; Flow Rate At 300kPa: 0.00776923 m3/s; Hand Shower Size: Ø110; Installation Type: Wall mounted; Installation Width: CC150± 15 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Easy-Grip surface;Eco feature for water flow; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Over Head Shower Size: Ø250; Pressure Loss With Flow 02ls: 250000 Pa; Shower Parts: Rotatable ball joint connection;Hand shower;;;Adjustable shower rail bracket;;Shower hose (1750 mm);Shower rail;Anti limescale technology (easy to clean);Twist guard for shower hose;Variable fixing points; Shower Spray: Normal;Massage;Rain; Shower Spray Number: 3 shower sprays; Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7192NU(2023); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 7192NU; Name: 7192NU Shower system; ReplacementCost: n/a; Shape: Sculptured; Size: 345 x 610 x 1240 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 7192NU Shower system; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7192NU; Manufacturer: Oras
Pset_ProductRequirements - Name: 7192NU Shower system; Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 1.39473 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.259425 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7192NU(2023): 7192NU Shower system; Family and Type: 7192NU(2023): 7192NU Shower system; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7192NU(2023): 7192NU Shower system; Type Id: 7192NU(2023): 7192NU Shower system; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
